ORG 00H

; C090
	MOV 40H, #39H
	MOV 41H, #3FH
	MOV 42H, #6FH
	MOV 43H, #0BFH
	
; C091
	MOV 44H, #39H
	MOV 45H, #3FH
	MOV 46H, #6FH
	MOV 47H, #86H

; C092
	MOV 48H, #39H
	MOV 49H, #3FH
	MOV 4AH, #6FH
	MOV 4BH, #0DBH

; C093
	MOV 4CH, #39H
	MOV 4DH, #3FH
	MOV 4EH, #6FH
	MOV 4FH, #0CFH
; C09
	MOV 50H, #39H
	MOV 51H, #3FH
	MOV 52H, #6FH

; DISPLAY
REPEAT: MOV R0, #40H
	MOV R4, #10H
LOOP1: MOV R7, #255
MAIN: MOV A, @R0
	SETB P2.0
	MOV P0, A
	ACALL DELAY
	CLR P2.0
	INC R0
	MOV A, @R0
	SETB P2.1
	MOV P0, A
	ACALL DELAY
	CLR P2.1
	INC R0
	MOV A, @R0
	SETB P2.2
	MOV P0, A
	ACALL DELAY
	CLR P2.2
	INC R0
	MOV A, @R0
	SETB P2.3
	MOV P0, A
	ACALL DELAY
	CLR P2.3
	DEC R0
	DEC R0
	DEC R0
	DJNZ R7, MAIN
	INC R0
	DJNZ R4, LOOP1
	AJMP REPEAT

DELAY: MOV R3, #02H
DEL1: MOV R2, #0FAH
DEL2: DJNZ R2, DEL2
	DJNZ R3, DEL1
	RET

	END